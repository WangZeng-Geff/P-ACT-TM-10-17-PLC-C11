# Keil uVision project sec67.uvproj, settings and files
target sec67 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: sec67 +hex
  AfterMake: fromelf --bin -o output/bin/sec67.bin output/sec67.axf
  c flags: Optim=1 OneElfS=1
  c define: SEC_HIGH
  c misc: --c99  --gnu
  c include: ..\..\sec67\public;..\..\sec67\SDK;..\..\sec67\user;..\..\sec67\SDK\socket;..\..\sec67\user;..\..\sec67\dev_ctrl;..\..\sec67\dev_ctrl\include;..\..\sec67\CMSIS;..\..\sec67\my
  memory RVCT4: ROM 0xd4000 size 0x18000
  memory RVCT9: RAM 0x200ce000 size 0x32000
  scatter file: .\output\sec67.sct
  group CMSIS
    ../../sec67/CMSIS/: core_cm3.h core_cmFunc.h core_cmInstr.h indefine.h ssc1667.h
  group dev_ctrl
    ../../sec67/dev_ctrl/include/: uart.c
  group public
    ../../sec67/public/: include.h types.h
  group sdk
    ../../sec67/SDK/: sdk.h sdk_evt.c sdk_evt.h sdk_svc.h
    ../../sec67/SDK/socket/: def.c def.h inet.h ip_addr.h sockets.h
  group startup
    ../../sec67/startup/: startup_ssc1667.s
  group user
    ../../sec67/user/: main.c cmd.h sec.h cmd.c
  group lib
    ../../sec67/lib/: sec67.lib
  group my
    ../../sec67/my/: crc32.c protocol.c sec_printf.c update.c repeater.c comfunc.c bitmap.c bitops.c dev_show.c sec_tick.c softtimer.c task.c esuart.c Motor_func.c
